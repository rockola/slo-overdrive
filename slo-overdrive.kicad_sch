File: slo-overdrive.kicad_sch (KiCad schematic)
At the start: 58 parts, among them IC1 TL064

Commit message: annotated
Parts:
- gave numbers to parts that had none: 57
